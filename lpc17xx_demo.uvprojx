# Keil uVision project lpc17xx_demo.uvprojx, settings and files
target lpc17xx_demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.4.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lpc17xx_demo +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin  -o  .\Objects\lpc17xx_demo.bin .\Objects\lpc17xx_demo.axf
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_M3, __LPC175X_6X__ ,USB_HOST_ONLY
  c misc: --c99 --gnu
  c include: .\CMSIS\Include;.\CMSIS\Device\NXP\LPC17XX\Include;.\CMSIS\Device\NXP\LPC17XX\Include\config_175x_6x;.\Libraries\inc;.\System\delay;.\System\sys;.\System\usart;.\FreeRTOSv9.0.0\Source\include;..\lpc17xx_freertos_demo_keil\FreeRTOSv9.0.0\Source\portable\RVDS\ARM_CM3;.\FreeRTOSv9.0.0;.\Tasks\UserTasks;.\LPCUSBLib\LPCUSBLibTask\lpcusblib_MassStorageHost;.\LPCUSBLib\Drivers\USB;.\filesystemsv0.13b;.\Software;.\User;.\Hardware\WWOG;.\Hardware\EMC;.\Hardware\LED;.\Hardware\USB;.\Hardware\RTC
  asm define: CORE_M4
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: .\Objects\lpc17xx_demo.sct
  group User
    ./User/: main.c board.c
  group Tasks
    ./Tasks/UserTasks/: usertask.c uarttask.c ledtask.c emctask.c usbtask.c
  group System
    ./System/delay/: delay.c
    ./System/sys/: sys.c
    ./System/usart/: usart.c
  group Hardware
    ./Hardware/LED/: led.c
    ./Hardware/EMC/: emc.c
    ./Hardware/USB/: usbhost.c
    ./Hardware/RTC/: rtc.c
  group Startup
    ./Startup/: keil_startup_lpc175x_6x.s
  group CMSIS
    ./CMSIS/Device/NXP/LPC17XX/Source/: chip_17xx_40xx.c sysinit.c
  group Libraries
    ./Libraries/src/: adc_17xx_40xx.c can_17xx_40xx.c clock_17xx_40xx.c cmp_17xx_40xx.c crc_17xx_40xx.c dac_17xx_40xx.c eeprom_17xx_40xx.c emc_17xx_40xx.c enet_17xx_40xx.c gpdma_17xx_40xx.c gpio_17xx_40xx.c gpioint_17xx_40xx.c i2c_17xx_40xx.c i2s_17xx_40xx.c iocon_17xx_40xx.c lcd_17xx_40xx.c pmu_17xx_40xx.c ritimer_17xx_40xx.c rtc_17xx_40xx.c sdc_17xx_40xx.c sdmmc_17xx_40xx.c spi_17xx_40xx.c ssp_17xx_40xx.c stopwatch_17xx_40xx.c sysctl_17xx_40xx.c sysinit_17xx_40xx.c timer_17xx_40xx.c uart_17xx_40xx.c wwdt_17xx_40xx.c eeprom.c fpu_init.c iap.c ring_buffer.c
  group FreeRTOSv9.0.0/Source
    ./FreeRTOSv9.0.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOSv9.0.0/Port
    ./FreeRTOSv9.0.0/Source/portable/RVDS/ARM_CM3/: port.c
    ./FreeRTOSv9.0.0/Source/portable/MemMang/: heap_4.c
    ./FreeRTOSv9.0.0/: FreeRTOSConfig.h
  group LPCUSBLib/Core
    ./LPCUSBLib/Drivers/USB/Class/Host/: MassStorageClassHost.c
    ./LPCUSBLib/Drivers/USB/Core/: Host.c HostStandardReq.c USBTask.c ConfigDescriptor.c USBMemory.c USBController.c Pipe.c PipeStream.c
    ./LPCUSBLib/Drivers/USB/Core/HCD/: HCD.c
    ./LPCUSBLib/Drivers/USB/Core/HAL/LPC17XX/: HAL_LPC17xx.c
    ./LPCUSBLib/Drivers/USB/Core/HCD/OHCI/: OHCI.c
  group LPCUSBLib/Task
    ./LPCUSBLib/LPCUSBLibTask/lpcusblib_MassStorageHost/: MassStorageHost.c fsusb_cfg.h
  group Filesystemv0.13b
    ./filesystemsv0.13b/: diskio.c ff.c ffsystem.c ffunicode.c ffconf.h
  group Software
    ./Software/: message_manager.c emc_loop_queue.c file_operation.c file_receive.c led_function.c system.h
